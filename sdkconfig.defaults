## sdkconfig.defaults
```kconfig
CONFIG_ESP_CONSOLE_NONE=y

CONFIG_BT_ENABLED=y

CONFIG_BT_NIMBLE_ENABLED=y

CONFIG_BT_NIMBLE_ROLE_CENTRAL_ENABLED=n
```
